# Keil uVision project USB-CANFD.uvprojx, settings and files
target USB-CANFD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G473CCTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: USB-CANFD +hex
  AfterMake: fromelf --bin -o "./USB-CANFD/USBCANFD-V1.0.0.bin" "./USB-CANFD/USB-CANFD.axf"
  c flags: Optim=2 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32G473xx,USE_HAL_DRIVER,STM32G473xx
  c include: ../Inc;                ../Drivers/STM32G4xx_HAL_Driver/Inc;                ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                ../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8009000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32g473xx.s
  group Application/User
    ../Src/: inter_flash.c tool.c main.c usb_data.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32g4xx_it.c stm32g4xx_hal_msp.c driver_ucan.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_gpio.c stm32g4xx_hal_pcd.c stm32g4xx_hal_pcd_ex.c stm32g4xx_ll_usb.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_ll_pwr.c stm32g4xx_hal_usart.c stm32g4xx_hal_usart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
software components: CMSIS:CORE 5.5.0
